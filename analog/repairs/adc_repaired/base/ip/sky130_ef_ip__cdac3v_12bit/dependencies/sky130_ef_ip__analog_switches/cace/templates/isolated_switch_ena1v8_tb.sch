** sch_path: analog/repairs/adc_repaired/base/ip/sky130_ef_ip__cdac3v_12bit/dependencies/sky130_ef_ip__analog_switches/cace/templates/isolated_switch_ena1v8_tb.sch
**.subckt isolated_switch_ena1v8_tb
V0 DVSS GND 0
V2 DVDD GND CACE{dvdd}
V1 AVSS GND 0
V3 AVDD GND CACE{avdd}
V4 ON GND CACE[CACE{dvdd} * CACE{enable}]
VIN IN GND ac 1
R1 OUT GND 1k m=1
x1 AVSS ON OUT IN AVDD DVDD DVSS isolated_switch_ena1v8
**** begin user architecture code


.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}

.include CACE{PDK_ROOT}/CACE{PDK}/libs.ref/sky130_fd_sc_hvl/spice/sky130_fd_sc_hvl.spice

.include CACE{DUT_path}

.temp CACE{temperature}




.control
    *save all

    * run op
    *op
    *write simplest_analog_switch_ena1v8_tb.raw
    *set appendwrite

    * run dc simulation
    dc vin 0 CACE{avdd} CACE{step}
    let r_switch = (v(in)-v(out))/-i(vin)

    meas DC r_switch_max max r_switch

    *write simplest_analog_switch_ena1v8_tb.raw

    echo $&r_switch_max > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
